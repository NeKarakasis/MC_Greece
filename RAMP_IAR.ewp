# IAR project RAMP_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA6T2BD Renesas R7FA6T2BD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src\application\main; C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src\application\tuner; C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src\application\user_interface\ics; C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src\application\user_interface; C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src\application; C:\Users\a5143778\Desktop\Customers\New_MC_Platform\RAMP_IAR\RAMP_IAR\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  OBJCOPY.OOCOutputFile: RAMP_IAR.srec
  ILINK.IlinkOutputFile: RAMP_IAR.elf
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_ofs_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_adc_b_cfg.h r_agt_cfg.h r_elc_cfg.h r_gpt_cfg.h r_gpt_three_phase_cfg.h r_ioport_cfg.h r_poeg_cfg.h rm_motor_control_cfg.h rm_motor_hal_driver_cfg.h rm_motor_pm_foc_cfg.h rm_motor_sensor_bemf_cfg.h rm_motor_trajectory_linear_cfg.h
  group Flex Software/Components/arm
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/board
    ra/board/ra6t2_mck/: board.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/fsp
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_adc_api.h r_elc_api.h r_ioport_api.h r_poeg_api.h r_three_phase_api.h r_timer_api.h r_transfer_api.h rm_motor_algorithm_api.h rm_motor_api.h rm_motor_hal_driver_api.h rm_motor_position_api.h rm_motor_sensor_api.h rm_motor_speed_api.h rm_motor_trajectory_api.h rm_motor_tuner_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_ipc.c bsp_ipc.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_mmf.h bsp_module_stop.h bsp_ospi_b.c bsp_ospi_b.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra6t2/: bsp_elc.h bsp_feature.h bsp_linker.c bsp_mcu_info.h bsp_override.h bsp_peripheral.h r_adc_device_types.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA6T2BD.h renesas.h system.h
    ra/fsp/src/r_adc_b/: r_adc_b.c
    ra/fsp/inc/instances/: r_adc_b.h r_agt.h r_elc.h r_gpt.h r_gpt_three_phase.h r_ioport.h r_poeg.h rm_motor_control.h rm_motor_hal_driver.h rm_motor_pm_foc.h rm_motor_sensor_bemf.h rm_motor_trajectory_linear.h
    ra/fsp/src/r_agt/: r_agt.c
    ra/fsp/src/r_elc/: r_elc.c
    ra/fsp/src/r_gpt/: r_gpt.c
    ra/fsp/src/r_gpt_three_phase/: r_gpt_three_phase.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_poeg/: r_poeg.c
    ra/fsp/lib/rm_motor_ctrllib/fpu32/: rm_motor_bemfobserver.c rm_motor_bemfobserver.h rm_motor_common.h rm_motor_decoupling.c rm_motor_decoupling.h rm_motor_extobserver.c rm_motor_extobserver.h rm_motor_filter.c rm_motor_filter.h rm_motor_fluxwkn.c rm_motor_fluxwkn.h rm_motor_fundlib.c rm_motor_fundlib.h rm_motor_gain_calc.c rm_motor_gain_calc.h rm_motor_mc_lib.h rm_motor_mtpa.c rm_motor_mtpa.h rm_motor_opl2less.c rm_motor_opl2less.h rm_motor_opl_damp_ctrl.c rm_motor_opl_damp_ctrl.h rm_motor_pi_control.c rm_motor_pi_control.h rm_motor_pi_gain_calc.c rm_motor_pi_gain_calc.h rm_motor_spdobserver.c rm_motor_spdobserver.h rm_motor_transform.c rm_motor_transform.h rm_motor_tuner_function.c rm_motor_tuner_function.h rm_motor_tuner_lib.h rm_motor_tuner_rls.c rm_motor_tuner_rls.h rm_motor_vlimit.c rm_motor_vlimit.h rm_motor_volt_error_comp.c rm_motor_volt_error_comp.h
    ra/fsp/src/rm_motor_control/: rm_motor_control.c
    ra/fsp/src/rm_motor_hal_driver/: rm_motor_hal_driver.c rm_motor_hal_driver_modulation.c rm_motor_hal_driver_modulation.h
    ra/fsp/src/rm_motor_pm_foc/: rm_motor_pm_foc.c rm_motor_pm_foc_inner.c rm_motor_pm_foc_inner.h rm_motor_pm_foc_internal.h rm_motor_pm_foc_outer.c rm_motor_pm_foc_outer.h rm_motor_pm_foc_outer_fnc.c rm_motor_pm_foc_outer_fnc.h
    ra/fsp/src/rm_motor_sensor_bemf/: rm_motor_sensor_bemf.c
    ra/fsp/lib/rm_motor_ctrllib/: rm_motor_shared_ccal_macros.h rm_motor_shared_ccal_types.h rm_motor_shared_data_foc.h rm_motor_shared_pos_speed_data.h
    ra/fsp/src/rm_motor_trajectory_linear/: rm_motor_trajectory_linear.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h elc_data.c hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c hal_warmstart.c parser.bat RAMP_IAR_conv.map ultimate_parser.py
    src/application/user_interface/ics/: ICS2_RA6T2.c ICS2_RA6T2.h OutputHeaderFileInfoForAnalyzer.xml r_mtr_ics.c r_mtr_ics.h RA6T2_MCB2_MCILV1_RAMP_E2S_V100.rmt
    src/application/main/: mtr_main.c mtr_main.h r_mtr_control_parameter.h r_mtr_motor_parameter.h r_mtr_trajectory_user.c
